## home-hub/main/Kconfig.projbuild
```kconfig
menu "Home Hub Configuration"

config INTERNET_TEST_HTTP
    bool "Enable HTTP WIFI Test"
    default n

endmenu
```
